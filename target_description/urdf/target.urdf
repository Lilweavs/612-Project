Commit message: final

File: target_description/urdf/target.urdf (robot description, URDF)
Before this commit: robot my_target, 2 links, 1 joints
Joints:
- joint fixed: origin xyz=3 0 0 rpy=0 0 0 -> xyz=2 0 0.3 rpy=0 0 0
